# IAR project rgb_platform.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207R8 STM8S207R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: rgb_platform.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: atascii.c command_interpreter.c command_interpreter.h delay.c delay.h eep.c eep.h i2c_bb.c i2c_bb.h pixel.c pixel.h random.c random.h rgb_platform_stm8s207.c rgb_platform_stm8s207.h scheduler.c scheduler.h stm8_hw_init.c stm8_hw_init.h tetris.c tetris.h uart.c uart.h
